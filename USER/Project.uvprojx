# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\TIMER;..\HARDWARE\ST7789;..\HARDWARE\DMA;..\HARDWARE\SPI;..\TASK;..\SoftWare\LVGL_8.3;..\SoftWare\LVGL_8.3\src;..\SoftWare\LVGL_8.3\examples\porting;..\SoftWare\GUI_Guider;..\SoftWare\GUI_Guider\custom;..\SoftWare\GUI_Guider\guider_customer_fonts;..\SoftWare\GUI_Guider\guider_fonts;..\SoftWare\GUI_Guider\images;..\SoftWare\GUI_Guider\myFont;..\SoftWare\GUI_Guider\myScreen;..\SoftWare\LVGL_8.3\demos\benchmark;..\HARDWARE\DHT11
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c FreeRTOS_task.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group TASK
    ../TASK/: MenuTask.c TimeTask.c CalendarTask.c ClockTask.c Dht11Task.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_spi.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti_x.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ST7789/: lcd_init.c lcd.c
    ../HARDWARE/DHT11/: dht11.c
  group FreeRTOS/Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group LVGL/myGUI
    ../SoftWare/GUI_Guider/myScreen/: MenuScreen.c TimeScreen.c ClockScreen.c CalendarScreen.c Dht11Screen.c
    ../SoftWare/GUI_Guider/myPic/: icon_calendar_64.c icon_clock_64.c icon_flashlight_64.c icon_settings_64.c icon_thermometer_64.c xn.c clock_img_64.c zz_img_64.c lovegame.c
    ../SoftWare/GUI_Guider/myFont/: menu_label_font_20px.c CelsiusSymbol.c
  group LVGL/conf
    ../SoftWare/LVGL_8.3/: lv_conf.h lvgl.h
  group LVGL/porting
    ../SoftWare/LVGL_8.3/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL/src
    ../SoftWare/LVGL_8.3/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../SoftWare/LVGL_8.3/src/draw/: lv_img_decoder.c lv_img_cache.c lv_img_buf.c lv_draw_triangle.c lv_draw_transform.c lv_draw_rect.c lv_draw_mask.c lv_draw_line.c lv_draw_layer.c lv_draw_label.c lv_draw_img.c lv_draw_arc.c lv_draw.c
    ../SoftWare/LVGL_8.3/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../SoftWare/LVGL_8.3/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../SoftWare/LVGL_8.3/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../SoftWare/LVGL_8.3/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../SoftWare/LVGL_8.3/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../SoftWare/LVGL_8.3/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../SoftWare/LVGL_8.3/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../SoftWare/LVGL_8.3/src/draw/arm2d/: lv_gpu_arm2d.c
    ../SoftWare/LVGL_8.3/src/extra/: lv_extra.c
    ../SoftWare/LVGL_8.3/src/extra/layouts/grid/: lv_grid.c
    ../SoftWare/LVGL_8.3/src/extra/layouts/flex/: lv_flex.c
    ../SoftWare/LVGL_8.3/src/extra/libs/bmp/: lv_bmp.c
    ../SoftWare/LVGL_8.3/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../SoftWare/LVGL_8.3/src/extra/libs/freetype/: lv_freetype.c
    ../SoftWare/LVGL_8.3/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../SoftWare/LVGL_8.3/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../SoftWare/LVGL_8.3/src/extra/libs/png/: lodepng.c lv_png.c
    ../SoftWare/LVGL_8.3/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../SoftWare/LVGL_8.3/src/extra/libs/rlottie/: lv_rlottie.c
    ../SoftWare/LVGL_8.3/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../SoftWare/LVGL_8.3/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../SoftWare/LVGL_8.3/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../SoftWare/LVGL_8.3/src/extra/others/gridnav/: lv_gridnav.c
    ../SoftWare/LVGL_8.3/src/extra/others/ime/: lv_ime_pinyin.c
    ../SoftWare/LVGL_8.3/src/extra/others/imgfont/: lv_imgfont.c
    ../SoftWare/LVGL_8.3/src/extra/others/monkey/: lv_monkey.c
    ../SoftWare/LVGL_8.3/src/extra/others/msg/: lv_msg.c
    ../SoftWare/LVGL_8.3/src/extra/others/snapshot/: lv_snapshot.c
    ../SoftWare/LVGL_8.3/src/extra/themes/basic/: lv_theme_basic.c
    ../SoftWare/LVGL_8.3/src/extra/themes/default/: lv_theme_default.c
    ../SoftWare/LVGL_8.3/src/extra/themes/mono/: lv_theme_mono.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/animimg/: lv_animimg.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/chart/: lv_chart.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/keyboard/: lv_keyboard.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/led/: lv_led.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/list/: lv_list.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/menu/: lv_menu.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/meter/: lv_meter.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/msgbox/: lv_msgbox.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/span/: lv_span.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/spinbox/: lv_spinbox.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/spinner/: lv_spinner.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/tabview/: lv_tabview.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/tileview/: lv_tileview.c
    ../SoftWare/LVGL_8.3/src/extra/widgets/win/: lv_win.c
    ../SoftWare/LVGL_8.3/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../SoftWare/LVGL_8.3/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../SoftWare/LVGL_8.3/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../SoftWare/LVGL_8.3/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group README
    ../: readme.txt
